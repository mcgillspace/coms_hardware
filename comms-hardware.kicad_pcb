# Repository mcgillspace/coms_hardware

File README.md:

# CSDC communications hardware

Hardware for the CSDC communications subsystem.

## License

&copy; 2016 Manos Theodoridis - APEL - University of Patras

&copy; 2016 Libre Space Foundation & commiters

Licensed under the [CERN OHLv1.2](LICENSE).

## KiCad design comms-hardware.kicad_pcb

Parts:
C1, C2: 20pF; 0603murata2
C3, C4, C53, C55: 100nF; 0402_cc
C5, C6, C12, C13, C15, C16, C18, C19, C21, C22, C23, C26, C57, C58, C71, C73, C77, C79, C83, C85, C89, C91, C93, C95: 47nF; 0402_cc
C7, C61: 220nF; 0402_cc
C8, C27, C30, C62, C96, C99: 10nF; 0402_cc
C9, C65: 22pF; 0402_cc
C10, C11, C67, C69: 15pF; 0402_cc
C14, C75: TBD; 0402_cc
C17, C81: 2.2uF; CC1120DecCAP
C20, C87: 1.8nF; 0402_cc
C24, C25, C38, C41, C42, C43, C45, C46, C48, C49, C137: 100nF; 0603murata2
C28, C29, C50: 1uF; 0603murata2
C31: 150 pF; 0402_cc
C32: 100 pF; 0402_cc
C33, C105: 100pF; 0402_cc
C34, C35, C37, C39: 15 pF; 0402_cc
C36, C40: 2.2uF; 0603murata2
C44: 18 pF; 0402_cc
C47: 1.8 pF; 0402_cc
C51, C52: 6.8pF; 0603murata2
C101: 39pF; 0402_cc
C103: 56pF; 0402_cc
C107: 2.2pF; 0402_cc
C109, C111, C113: 5.1pF; 0402_cc
C115: 6.2pF; 0402_cc
C117: 0.1uF; 0603murata2
C118: do not mount; 0402_cc
C121, C153: 3.3uF; 0603murata2
C123, C125, C141, C147: 10000pF; 0603murata2
C127, C129, C143, C152: 1nF; 0603murata2
C131, C132: 330pF; 0603murata2
C135, C169: 56pF; 0603murata2
C139, C145: 18pF; 0603murata2
C149, C151: 47pF; 0603murata2
C157: TBD; 0603murata2
C159: 6.8 pF; 0603murata2
C160: 22 pF; 0603murata2
C164: 4 pF; 0603murata2
J1, J2: SMA; sma_smd_samtec_man
L1, L11: BLM15HG102SN1D; 0402_cc
L2: 150 nH; 0402_cc
L3: 180 nH; 0402_cc
L4: fcm1608-0603; 0603murata2
L5: 19 nH; 0402_cc
L6, L7: 91 nH; 0402_cc
L8: 120 nH; 0402_cc
L9: 43 nH; 0402_cc
L10: 75 nH; 0402_cc
L13, L15: 56nH; 0402_cc
L17, L25: 15nH; 0402_cc
L19, L21: 27nH; 0402_cc
L23: 43nH; 0402_cc
L27: 22nH; 0402_cc
L29: 6.8nH; 0603murata2
L31: Taiyo Yuden; Taiyo_Yuden_bead
L33: 4.3 nH; 0603murata2
P1: SWD; hrs-df11-6dp-2dsa
P2: OBC; hrs-df11-6dp-2dsa
P3: CONN_02X03; hrs-df11-6dp-2dsa
R3, R43, R45: 10K; 0603murata2
R5: 220; 0603murata2
R8, R9, R10, R24, R26, R27, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73: 0; 0402_cc
R17, R32: 56K; 0402_cc
R18: 47; 0603murata2
R19: 22 Ohm; 0402_cc
R20, R47: 0; 0603murata2
R30, R31, R34, R35, R36, R37, R38, R41: 470; 0603murata2
R39: 18; 0402_cc
R49: 180; 0603murata2
R51: 18; 0603murata2
R53: 180 Ohm; 0603murata2
RFSHIELD1: TEST_1P; BMI-S-x06
U1, U6: TXCO_TG_5021CG; TXCOTG5021CG
U2, U8: TPS79930; sot23-5
U3, U18: FA_128_; crystal_fa128
U4, U10: CC1120; cc1120
U5: STM32F407VG; TQFP-100
U12: ADT7420
U14: OPA320; sot23-5
U16: RF5110G
Y1: Crystal; ABM3crystal
Y2: Crystal; ABS07crystal

Connections:
+3V3: C4.1, C38.1, C41.1, C42.1, C43.1, C45.1, C46.1, C48.1, C49.1, C50.1, C55.1, C117.1, C121.1, C123.1, C125.1, C127.1, C129.1, C131.1, C137.1, C149.1, C151.2, C152.2, C153.2, L1.2, L4.2, L11.2, L31.2, P3.3, P3.4, R3.2, R43.1, R45.1, R47.1, R51.1, U2.1 (IN), U2.3 (EN), U5.6 (VBAT), U5.11 (VDD), U5.19 (VDD), U5.28 (VDD), U5.50 (VDD), U5.75 (VDD), U5.100 (VDD), U8.1 (IN), U8.3 (EN), U12.12 (VDD), U14.5 (V+), U16.14 (VCC); also elsewhere on the board
/1CS_N: R73.1, U5.77 (PA15/JTDI/SPI3_NSS/I2S3_WS/TIM2_CH1_ETR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)
/1GPIO0: R72.1, U5.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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)
/1GPIO2: R68.1, U5.26 (PA3/USART2_RX/TIM5_CH4/TIM9_CH2/TIM2_CH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)
/1GPIO3: R67.1, U5.25 (PA2/USART2_TX/TIM5_CH3/TIM9_CH1/TIM2_CH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)
/1RESET_N: R66.1, U5.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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)
/2CS_N: R65.1, U5.46 (PE15/FSMC_D12/TIM1_BKIN/EVENTOUT)
/2GPIO0: R64.1, U5.51 (PB12/SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_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)
/2GPIO2: R60.1, U5.40 (PE9/FSMC_D6/TIM1_CH1/EVENTOUT)
/2GPIO3: R59.1, U5.38 (PE7/FSMC_D4/TIM1_ETR/EVENTOUT)
/2RESET_N: R58.1, U5.36 (PB1/TIM3_CH4/TIM8_CH3N/OTG_HS_ULPI_D2/E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)
/COMMS_TO_OBC_EN: R38.2, U5.84 (PD3/FSMC_CLK/USART2_CTS/EVENTOUT)
/COMMS_TO_OBC_RX: R41.1, U5.83 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD/DCMI_D11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)
/COMMS_TO_OBC_TX: R37.2, U5.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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)
/DAC_OUT2: U5.30 (PA5/SPI1_SCK/OTG_HS_ULPI_CK/TIM2_CH1_ET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), U14.3 (+)
/I2C1_SCL: R45.2, U5.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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), U12.1 (SCL)
/I2C1_SDA: R43.2, U5.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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), U12.2 (SDA)
/NRST: R3.1, R35.1, U5.14 (NRST)
/SPI1_MISO: R71.1, U5.31 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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)
/SPI1_MOSI: R69.1, U5.32 (PA7/SPI1_MOSI/TIM8_CH1N/TIM14_CH1/TIM3_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)
/SPI1_SCK: R70.1, U5.89 (PB3/JTDO/TRACESWO/SPI3_SCK/I2S3_CK/TIM2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)
/SPI2_MISO: R63.1, U5.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
/SPI2_MOSI: R61.1, U5.54 (PB15/SPI2_MOSI/I2S2_SD/TIM1_CH3N/TIM8_C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)
/SPI2_SCK: R62.1, U5.52 (PB13/SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_C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)
/SWCLK: R34.1, U5.76 (PA14/JTCK/SWCLK/EVENTOUT)
/SWDIO: R30.2, U5.72 (PA13/JTMS/SWDIO/EVENTOUT)
/USART3_RX: R36.1, U5.48 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
/USART3_TX: R31.2, U5.47 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.1, C11.1, C12.1, C13.2, C14.1, C15.2, C16.1, C17.2, C18.2, C19.1, C21.1, C22.2, C23.1, C24.2, C25.1, C26.1, C27.1, C28.2, C29.1, C30.2, C33.2, C35.1, C36.2, C38.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C48.2, C49.2, C50.2, C51.1, C52.1, C53.2, C55.2, C57.2, C58.2, C61.2, C62.2, C67.1, C69.1, C71.1, C73.2, C75.1, C77.2, C79.1, C81.2, C83.2, C85.1, C89.1, C91.2, C93.1, C95.1, C96.1, C99.2, C105.2, C109.1, C115.2, C117.2, C121.2, C123.2, C125.2, C127.2, C129.2, C131.2, C132.2, C137.2, C139.2, C141.2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; also elsewhere on the board
unnamed: C1.2, U5.12 (PH0/OSC_IN/EVENTOUT), Y1.1
unnamed: C2.2, R5.2, Y1.2
unnamed: C3.1, R8.2, R9.1, U1.4 (VCC)
unnamed: C7.1, U4.6 (DCPL)
unnamed: C8.1, U2.4 (NR)
unnamed: C9.1, R10.2, U4.32 (EXT_XOSC)
unnamed: C9.2, U1.3 (OUT)
unnamed: C10.2, U3.1, U4.31 (XOSC_Q2)
unnamed: C11.2, C14.2, U3.3, U4.30 (XOSC_Q1)
unnamed: C12.2, R9.2, U4.29 (DCPL_XOSC)
unnamed: C20.1, U4.23 (LPF0)
unnamed: C20.2, U4.24 (LPF1)
unnamed: C21.2, U4.26 (DCPL_PFD_CHP)
unnamed: C24.1, C28.1, R18.1, U5.21 (VREF+)
unnamed: C25.2, C29.2, L4.1, R18.2, U5.22 (VDDA)
unnamed: C27.2, U4.21 (DCPL_VCO)
unnamed: C31.1, C34.2, L5.2
unnamed: C31.2, L2.1, U4.17 (PA)
unnamed: C32.1, L2.2, R19.1
unnamed: C34.1, C39.2, L5.1, L8.2
unnamed: C35.2, L3.1, L6.2, U4.20 (LNA_N)
unnamed: C36.1, U5.49 (VCAP_1)
unnamed: C37.1, L6.1, L9.1
unnamed: C37.2, L3.2, L7.2, U4.19 (LNA_P)
unnamed: C39.1, L9.2, U4.18 (TRX_SW)
unnamed: C40.1, U5.73 (VCAP_2)
unnamed: C44.1, C47.2, L8.1, L10.2
unnamed 56: C47.1, J1.1 (RF), L10.1; also elsewhere on the board
unnamed: C51.2, U5.8 (PC14/OSC32_IN/EVENTOUT), Y2.1
unnamed: C52.2, U5.9 (PC15/OSC32_OUT/EVENTOUT), Y2.2
unnamed: C53.1, R24.2, R26.1, U6.4 (VCC)
unnamed: C61.1, U10.6 (DCPL)
unnamed: C62.1, U8.4 (NR)
unnamed: C65.1, R27.2, U10.32 (EXT_XOSC)
unnamed: C65.2, U6.3 (OUT)
unnamed: C67.2, U10.31 (XOSC_Q2), U18.1
unnamed: C69.2, C75.2, U10.30 (XOSC_Q1), U18.3
unnamed: C71.2, R26.2, U10.29 (DCPL_XOSC)
unnamed: C87.1, U10.23 (LPF0)
unnamed: C87.2, U10.24 (LPF1)
unnamed: C89.2, U10.26 (DCPL_PFD_CHP)
unnamed: C96.2, U10.21 (DCPL_VCO)
unnamed: C101.1, C107.2, L17.2
unnamed: C101.2, L13.1, U10.17 (PA)
unnamed: C103.1, L13.2, R39.1
unnamed: C107.1, C113.2, L17.1, L23.2
unnamed: C109.2, L15.1, L19.2, U10.20 (LNA_N)
unnamed: C111.1, L19.1, L25.1
unnamed: C111.2, L15.2, L21.2, U10.19 (LNA_P)
unnamed: C113.1, L25.2, U10.18 (TRX_SW)
unnamed: C115.1, C118.2, L23.1, L27.2
unnamed: C118.1, C135.2, L27.1, R49.1
unnamed: C132.1, L29.2, R47.2
unnamed: C135.1, U16.3 (RF_IN)
unnamed: C139.1, L29.1, U16.5 (VCC2), U16.6 (VCC2)
unnamed: C141.1, C143.1, C147.1, R53.2, U16.15 (APC2), U16.16 (APC1)
unnamed: C145.1, U16.8 (2F0)
unnamed: C157.2, L31.1, L33.2, U16.9 (RF_OUT), U16.10 (RF_OUT), U16.11 (RF_OUT), U16.12 (RF_OUT)
unnamed: C159.2, C160.1, C164.1, C169.2, L33.1
unnamed 88: C169.1, J2.1 (RF); also elsewhere on the board
unnamed 89: P1.2, R34.2; also elsewhere on the board
unnamed 90: P1.3, R30.1; also elsewhere on the board
unnamed 91: P1.4, R35.2; also elsewhere on the board
unnamed 92: P1.5, R31.1; also elsewhere on the board
unnamed 93: P1.6, R36.2; also elsewhere on the board
unnamed 94: P2.3, R37.1; also elsewhere on the board
unnamed 95: P2.4, R41.2; also elsewhere on the board
unnamed 96: P2.5, R38.1; also elsewhere on the board
unnamed: R5.1, U5.13 (PH1/OSC_OUT/EVENTOUT)
unnamed: R17.1, U4.14 (RBIAS)
unnamed: R20.1, U5.99 (VSS)
unnamed: R32.1, U10.14 (RBIAS)
unnamed: R51.2, U16.1 (VCC1)
unnamed: R53.1, U14.1 (OUT), U14.4 (-)
unnamed: R58.2, U4.2 (RESET_N)
unnamed: R59.2, U4.3 (GPIO3)
unnamed: R60.2, U4.4 (GPIO2)
unnamed: R61.2, U4.7 (SI)
unnamed: R62.2, U4.8 (SCLK)
unnamed: R63.2, U4.9 (SO(GPIO1))
unnamed: R64.2, U4.10 (GPIO0)
unnamed: R65.2, U4.11 (CSn)
unnamed: R66.2, U10.2 (RESET_N)
unnamed: R67.2, U10.3 (GPIO3)
unnamed: R68.2, U10.4 (GPIO2)
unnamed: R69.2, U10.7 (SI)
unnamed: R70.2, U10.8 (SCLK)
unnamed: R71.2, U10.9 (SO(GPIO1))
unnamed: R72.2, U10.10 (GPIO0)
unnamed: R73.2, U10.11 (CSn)
VDD: C5.1, C6.1, C13.1, C15.1, C16.2, C17.1, C18.1, C19.2, C22.1, C23.2, C26.2, C30.1, C32.2, C33.1, C57.1, C58.1, C73.1, C77.1, C79.2, C81.1, C83.1, C85.2, C91.1, C93.2, C95.2, C99.1, C103.2, C105.1, L1.1, L11.1, R8.1, R19.2, R24.1, R39.2, U2.5 (OUT), U4.1 (VDD_GUARD), U4.5 (DVDD), U4.12 (DVDD), U4.13 (AVDD_IF), U4.15 (AVDD_RF), U4.22 (AVDD_SYNTH1), U4.25 (AVDD_PFD_CHP), U4.27 (AVDD_SYNTH2), U4.28 (AVDD_XOSC), U8.5 (OUT), U10.1 (VDD_GUARD), U10.5 (DVDD), U10.12 (DVDD), U10.13 (AVDD_IF), U10.15 (AVDD_RF), U10.22 (AVDD_SYNTH1), U10.25 (AVDD_PFD_CHP), U10.27 (AVDD_SYNTH2), U10.28 (AVDD_XOSC)

Notes on the sheet:
MY boot B0=GND B1=X DISCO boot B0=PULLUP VDD B1=X
L1 is a Bead to be mounted if the regulator U2 is not mounted, CC1120 ref des will default not use regulator CC1120/CC1125: do not mount: U2, C4, C8, C13 TG5021CG is optional: do not mount L1 if regulator is mounted
CC1120/25 uning XTAL: do not mount: U1, C3, C9, R9, R6 CC1120/25 using TCXO: do not mount: R10, R9, C10, U3, C11: mount 0 Ohm resisitor X1: CC1120:32MHz and CC1125:40MHz R10 is a 0ohms shunt resistor that ground the EXT_XOSC pin when TCXO is not mounted.
na dw edw
CC1120/25 uning XTAL: do not mount: U6, C53, C65, R26, R24 CC1120/25 using TCXO: do not mount: R27, R26, C67, U18, C69: mount 0 Ohm resistor X1: CC1120:32MHz and CC1125:40MHz R27 is a 0ohms shunt resistor that ground the EXT_XOSC pin when TCXO is not mounted.
Address 0x48
L11 is a Bead to be mounted if the regulator U8 is not mounted, CC1120 ref des will default not use regulator CC1120/CC1125: do not mount: U8, C55, C62, C73 TG5021CG is optional: do not mount L1 if regulator is mounted
MCU
CON

Board: 4 copper layers, 92.5 x 92.5 mm, 195 parts (2 on the bottom side), 120 nets.

Other parts of the board:
EPS: CONN_02X03; hrs-df11-6dp-2dsa
OBC: OBC; hrs-df11-6dp-2dsa
SWD: SWD; hrs-df11-6dp-2dsa
UHF: SMA; mmcx_conn
VHF: SMA; mmcx_conn

Their connections:
+3V3: EPS.3, EPS.4; also elsewhere on the board
GND: EPS.1, EPS.2, EPS.5, EPS.6, OBC.1, OBC.2, SWD.1, UHF.2, UHF.3, UHF.4, UHF.5, VHF.2, VHF.3, VHF.4, VHF.5; also elsewhere on the board
unnamed 56: VHF.1; also elsewhere on the board
unnamed 88: UHF.1; also elsewhere on the board
unnamed 89: SWD.2; also elsewhere on the board
unnamed 90: SWD.3; also elsewhere on the board
unnamed 91: SWD.4; also elsewhere on the board
unnamed 92: SWD.5; also elsewhere on the board
unnamed 93: SWD.6; also elsewhere on the board
unnamed 94: OBC.3; also elsewhere on the board
unnamed 95: OBC.4; also elsewhere on the board
unnamed 96: OBC.5; also elsewhere on the board

## Commit log

2018-02-10 First commit, added Upsat's files, added missing KiCad libraries
2018-02-27 Added MSG Logo on board, modified mounting holes dimensions, modified some copper tracks location
2018-03-08 Finalized PCB Gerbers for first prototype printing
2018-03-10 Generated BOM, Fixed Mouting Holes dimensions and positions, Fixed 3D Libraries references
2018-03-12 Generated CSV BOM
